# Keil uVision project TP.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: TP
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c test.s DRAW.c LAB_746_DISC.c PATTERN.s
software components: CMSIS:CORE 5.4.0, Board Support:Drivers:SDRAM 1.1.1, Board Support:Graphic LCD 1.1.1, Device:STM32Cube Framework:Classic 1.2.8, Device:STM32Cube HAL:Common 1.2.8, Device:STM32Cube HAL:Cortex 1.2.8, Device:STM32Cube HAL:DAC 1.2.8, Device:STM32Cube HAL:DMA 1.2.8, Device:STM32Cube HAL:EXTI 1.2.8, Device:STM32Cube HAL:Flash 1.2.8, Device:STM32Cube HAL:GPIO 1.2.8, Device:STM32Cube HAL:LTDC 1.2.8, Device:STM32Cube HAL:PWR 1.2.8, Device:STM32Cube HAL:RCC 1.2.8, Device:STM32Cube HAL:SDRAM 1.2.8, Device:STM32Cube HAL:SPI 1.2.8, Device:STM32Cube HAL:TIM 1.2.8, Device:Startup 1.2.5
